v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/lab_pin.sym} -140 0 0 0 {name=l1 sig_type=std_logic lab=b_vinp}
C {devices/lab_pin.sym} -140 20 0 0 {name=l2 sig_type=std_logic lab=b_vinm}
C {devices/lab_pin.sym} -140 40 0 0 {name=l3 sig_type=std_logic lab=b_vbias}
C {devices/lab_pin.sym} -140 60 0 0 {name=l4 sig_type=std_logic lab=b_clkout_p}
C {devices/lab_pin.sym} -140 80 0 0 {name=l5 sig_type=std_logic lab=b_clkout_n}
C {devices/lab_pin.sym} -140 100 0 0 {name=l6 sig_type=std_logic lab=b_VDPWR}
C {devices/lab_pin.sym} -140 120 0 0 {name=l7 sig_type=std_logic lab=b_VGND}
C {cml/ctle_cdr_rx_cml_bg.sym} 0 0 0 0 {name=x1}
