v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/lab_pin.sym} -140 0 0 0 {name=l1 sig_type=std_logic lab=a_vinp}
C {devices/lab_pin.sym} -140 20 0 0 {name=l2 sig_type=std_logic lab=a_vinm}
C {devices/lab_pin.sym} -140 40 0 0 {name=l3 sig_type=std_logic lab=a_vbias}
C {devices/lab_pin.sym} -140 60 0 0 {name=l4 sig_type=std_logic lab=a_clkout_p}
C {devices/lab_pin.sym} -140 80 0 0 {name=l5 sig_type=std_logic lab=a_clkout_n}
C {devices/lab_pin.sym} -140 100 0 0 {name=l6 sig_type=std_logic lab=a_VDPWR}
C {devices/lab_pin.sym} -140 120 0 0 {name=l7 sig_type=std_logic lab=a_VGND}
C {cml/ctle_cdr_rx_cml.sym} 0 0 0 0 {name=x1}
C {devices/lab_pin.sym} -140 400 0 0 {name=l8 sig_type=std_logic lab=b_vinp}
C {devices/lab_pin.sym} -140 420 0 0 {name=l9 sig_type=std_logic lab=b_vinm}
C {devices/lab_pin.sym} -140 440 0 0 {name=l10 sig_type=std_logic lab=b_vbias}
C {devices/lab_pin.sym} -140 460 0 0 {name=l11 sig_type=std_logic lab=b_clkout_p}
C {devices/lab_pin.sym} -140 480 0 0 {name=l12 sig_type=std_logic lab=b_clkout_n}
C {devices/lab_pin.sym} -140 500 0 0 {name=l13 sig_type=std_logic lab=b_VDPWR}
C {devices/lab_pin.sym} -140 520 0 0 {name=l14 sig_type=std_logic lab=b_VGND}
C {cml/ctle_cdr_rx_cml_bg.sym} 0 400 0 0 {name=x2}
