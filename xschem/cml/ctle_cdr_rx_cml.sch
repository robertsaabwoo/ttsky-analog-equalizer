v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} -400 0 0 0 {name=p1 lab=vinp}
C {devices/iopin.sym} -400 40 0 0 {name=p2 lab=vinm}
C {devices/iopin.sym} -400 80 0 0 {name=p3 lab=vbias}
C {devices/iopin.sym} -400 120 0 0 {name=p4 lab=clkout_p}
C {devices/iopin.sym} -400 160 0 0 {name=p5 lab=clkout_n}
C {devices/iopin.sym} -400 200 0 0 {name=p6 lab=VDPWR}
C {devices/iopin.sym} -400 240 0 0 {name=p7 lab=VGND}
C {devices/lab_pin.sym} 350 -30 0 0 {name=l1 sig_type=std_logic lab=eq_p}
C {devices/lab_pin.sym} 350 -10 0 0 {name=l2 sig_type=std_logic lab=eq_m}
C {devices/lab_pin.sym} 50 -30 0 0 {name=l3 sig_type=std_logic lab=vinp}
C {devices/lab_pin.sym} 50 -10 0 0 {name=l4 sig_type=std_logic lab=vinm}
C {devices/lab_pin.sym} 350 10 0 0 {name=l5 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 350 30 0 0 {name=l6 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 50 10 0 0 {name=l7 sig_type=std_logic lab=vbias}
C {CTLE.sym} 200 0 0 0 {name=x1}
C {devices/lab_pin.sym} 320 0 0 0 {name=l8 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 320 20 0 0 {name=l9 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 320 40 0 0 {name=l10 sig_type=std_logic lab=eq_p}
C {devices/lab_pin.sym} 320 60 0 0 {name=l11 sig_type=std_logic lab=eq_m}
C {devices/lab_pin.sym} 320 80 0 0 {name=l12 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 320 100 0 0 {name=l13 sig_type=std_logic lab=rclk_p}
C {devices/lab_pin.sym} 320 120 0 0 {name=l14 sig_type=std_logic lab=rclk_m}
C {cml/CDR_cml.sym} 460 0 0 0 {name=x2}
C {devices/lab_pin.sym} 870 -20 0 0 {name=l15 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 870 0 0 0 {name=l16 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 570 -20 0 0 {name=l17 sig_type=std_logic lab=rclk_p}
C {devices/lab_pin.sym} 870 20 0 0 {name=l18 sig_type=std_logic lab=clkout_p}
C {inverter_chain.sym} 720 0 0 0 {name=x3}
C {devices/lab_pin.sym} 1130 -20 0 0 {name=l19 sig_type=std_logic lab=VDPWR}
C {devices/lab_pin.sym} 1130 0 0 0 {name=l20 sig_type=std_logic lab=VGND}
C {devices/lab_pin.sym} 830 -20 0 0 {name=l21 sig_type=std_logic lab=rclk_m}
C {devices/lab_pin.sym} 1130 20 0 0 {name=l22 sig_type=std_logic lab=clkout_n}
C {inverter_chain.sym} 980 0 0 0 {name=x4}
