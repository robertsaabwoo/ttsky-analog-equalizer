v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} -400 0 0 0 {name=p1 lab=Q}
C {devices/iopin.sym} -400 40 0 0 {name=p2 lab=Qb}
C {devices/iopin.sym} -400 80 0 0 {name=p3 lab=D}
C {devices/iopin.sym} -400 120 0 0 {name=p4 lab=Db}
C {devices/iopin.sym} -400 160 0 0 {name=p5 lab=VDD}
C {devices/iopin.sym} -400 200 0 0 {name=p6 lab=VSS}
C {devices/iopin.sym} -400 240 0 0 {name=p7 lab=ck}
C {devices/iopin.sym} -400 280 0 0 {name=p8 lab=ckb}
C {devices/iopin.sym} -400 320 0 0 {name=p9 lab=vbias}
C {devices/lab_pin.sym} 60 0 0 0 {name=l1 sig_type=std_logic lab=m}
C {devices/lab_pin.sym} 60 20 0 0 {name=l2 sig_type=std_logic lab=mb}
C {devices/lab_pin.sym} 60 40 0 0 {name=l3 sig_type=std_logic lab=D}
C {devices/lab_pin.sym} 60 60 0 0 {name=l4 sig_type=std_logic lab=Db}
C {devices/lab_pin.sym} 60 80 0 0 {name=l5 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 60 100 0 0 {name=l6 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 60 120 0 0 {name=l7 sig_type=std_logic lab=ckb}
C {devices/lab_pin.sym} 60 140 0 0 {name=l8 sig_type=std_logic lab=ck}
C {devices/lab_pin.sym} 60 160 0 0 {name=l9 sig_type=std_logic lab=vbias}
C {cml/cml_latch.sym} 200 0 0 0 {name=xm}
C {devices/lab_pin.sym} 320 0 0 0 {name=l10 sig_type=std_logic lab=Q}
C {devices/lab_pin.sym} 320 20 0 0 {name=l11 sig_type=std_logic lab=Qb}
C {devices/lab_pin.sym} 320 40 0 0 {name=l12 sig_type=std_logic lab=m}
C {devices/lab_pin.sym} 320 60 0 0 {name=l13 sig_type=std_logic lab=mb}
C {devices/lab_pin.sym} 320 80 0 0 {name=l14 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 320 100 0 0 {name=l15 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 320 120 0 0 {name=l16 sig_type=std_logic lab=ck}
C {devices/lab_pin.sym} 320 140 0 0 {name=l17 sig_type=std_logic lab=ckb}
C {devices/lab_pin.sym} 320 160 0 0 {name=l18 sig_type=std_logic lab=vbias}
C {cml/cml_latch.sym} 460 0 0 0 {name=xs}
